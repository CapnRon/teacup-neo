# Repository CapnRon/teacup-neo (continued)

## KiCad design hw/teacup-carrier.kicad_pcb

Schematic: teacup-carrier.kicad_sch, Teacup Universal - Carrier Board

Parts:
C1, C9, C10, C11, C18: 22uF; C_0805_2012Metric
C2, C3, C7, C12, C17, C22, C24, C25, C26: 100nF; C_0402_1005Metric
C4: 1uF; C_0402_1005Metric
C5: 4.7nF; C_0402_1005Metric
C6, C15, C16, C20, C21, C27, C28, C29: 10uF; C_0805_2012Metric
C13, C23: 1nF_TBD; C_0402_1005Metric
C14, C19: 1uF; C_0603_1608Metric
D1, D2: PMEG2010ER; D_SOD-123W
J1: AH58893-T9B10-3F; DDR4288S0511H_UDIMM288
J2, J9: TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3: TE_292303-7; USB_A_TE_292303-7_Horizontal
J4: Hirose_DM3D-SF; microSD_HC_Hirose_DM3D-SF
J5: Wuerth_694106301002; BarrelJack_Wuerth_6941xx301002
J6: AudioJack4_Ground; Jack_3.5mm_PJ320D_Horizontal
J7, J8: SFW15R-2STE1LF; FPC-SMD_15P-P1.00_SFW15R-2STE1LF
J20: HDR_J20; PinHeader_1x11_P2.54mm_Vertical
J21: HDR_J21; PinHeader_1x11_P2.54mm_Vertical
J22: HDR_J22; PinHeader_1x05_P2.54mm_Vertical
J23: HDR_J23; PinHeader_1x05_P2.54mm_Vertical
J24: HDR_J24; PinHeader_1x05_P2.54mm_Vertical
J25: HDR_J25; PinHeader_1x07_P2.54mm_Vertical
J26: HDR_J26; PinHeader_1x05_P2.54mm_Vertical
J27: HDR_J27; PinHeader_1x09_P2.54mm_Vertical
J28: HDR_J28; PinHeader_1x02_P2.54mm_Vertical
J29: HDR_J29; PinHeader_1x05_P2.54mm_Vertical
J30: HDR_J30; PinHeader_1x17_P2.54mm_Vertical
J31: HDR_J31; PinHeader_1x24_P2.54mm_Vertical
J32: HDR_J32; PinHeader_1x25_P2.54mm_Vertical
J33: HDR_J33; PinHeader_1x25_P2.54mm_Vertical
J34: HDR_J34; PinHeader_1x25_P2.54mm_Vertical
J35: HDR_J35; PinHeader_1x25_P2.54mm_Vertical
JP2: 0.8V; PinHeader_1x02_P2.54mm_Vertical
JP3: 0.9V; PinHeader_1x02_P2.54mm_Vertical
JP4: 1.0V; PinHeader_1x02_P2.54mm_Vertical
JP5: 1.1V; PinHeader_1x02_P2.54mm_Vertical
JP6, JP10: COMPUTER; PinHeader_1x02_P2.54mm_Vertical
JP7: 1.35V; PinHeader_1x02_P2.54mm_Vertical
JP8: 1.5V; PinHeader_1x02_P2.54mm_Vertical
JP9: 1.8V; PinHeader_1x02_P2.54mm_Vertical
L1, L2, L3: 2.2uH; L_1210_3225Metric
Q1, Q2: AO3401A; SOT-23
R1, R3, R5, R15, R17, R20, R22: 100k; R_0402_1005Metric
R2, R4, R7, R8, R9, R10, R11, R14, R24: 10k; R_0402_1005Metric
R6: 31.6k; R_0402_1005Metric
R12, R13, R18, R19: 5.1k; R_0402_1005Metric
R16, R25, R26, R41, R42: 4.7k; R_0402_1005Metric
R21, R23: 1k; R_0402_1005Metric
R27: 3.32k; R_0402_1005Metric
R28, R30, R32, R34, R36, R38, R40: 10.0k; R_0402_1005Metric
R29: 4.99k; R_0402_1005Metric
R31: 6.65k; R_0402_1005Metric
R33: 8.25k; R_0402_1005Metric
R35: 6.81k; R_0402_1005Metric
R37: 8.66k; R_0402_1005Metric
R39: 12.4k; R_0402_1005Metric
SW1, SW2: SSSS711403; SW-TH_SSSS711403
U1: AP62600SJ-7; QFN-12_L3.0-W2.0-P0.50-TL_AP62600SJ-7
U2, U7: AP62300WU-7; TSOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL
U3: MCP4661-104E_ST; TSSOP-14_4.4x5mm_P0.65mm
U4, U14: TPS22990DMLR; WSON-10_L3.0-W2.0-P0.50-BL-EP_TI_DML
U5: AZ1117CH-3.3TRG1; SOT-223-3_TabPin2
U6: AZ1117CH-1.8TRG1; SOT-223-3_TabPin2
U8: ESP32-S3-WROOM-1-N16R2; ESP32-S3-WROOM-1
U9, U10: TS5A3166; SOT-23-5
U11: DIP-8 Socket; DIP-8_W7.62mm_Socket
U12: TPS2053BDR; SOIC-16_3.9x9.9mm_P1.27mm
U13: W25Q32JVSS; SOIC-8_5.23x5.23mm_P1.27mm
U15: TCA9555PWR; TSSOP-24_4.4x7.8mm_P0.65mm

Connections:
+1V8: C20.1, J1.15, J1.16, U6.3 (OUT)
+3V3: C12.1, C18.1, C19.1, C24.1, C25.1, C26.1, J1.13, J1.14, J4.4 (VDD), J7.5, J8.5, L3.2, R2.1, R3.1, R4.1, R6.1, R8.1, R9.1, R10.1, R11.1, R14.1, R24.1, R25.1, R26.1, R41.1, R42.1, U3.11 (WP), U3.14 (VDD), U6.1 (IN), U9.5 (V+), U10.5 (V+), U11.8 (VCC), U13.8 (VCC), U15.24 (VCC)
+3V3_ALWAYS: C15.1, C21.1, C22.1, U5.3 (OUT), U8.2 (3V3)
+5V_ALT: C28.1, D2.2 (A), Q1.3 (D), Q2.3 (D), SW2.3, U14.3 (VIN), U14.4 (VBIAS), U14.11 (VIN)
+5V_BMC: C27.1, D1.2 (A), J9.A4 (VBUS), J9.A9 (VBUS), J9.B4 (VBUS), J9.B9 (VBUS), U4.3 (VIN), U4.4 (VBIAS), U4.11 (VIN)
+5V_MODEA: J1.17, J1.18
+5V_SW: C1.1, C2.1, C6.1, C16.1, R1.1, R5.1, U1.2 (VIN), U2.3 (VIN), U4.8 (VOUT), U4.9 (VOUT), U4.10 (VOUT), U7.3 (VIN), U12.2 (IN1), U12.6 (IN2), U14.8 (VOUT), U14.9 (VOUT), U14.10 (VOUT)
/ESP32_CONSOLE_RX: U8.36 (U0RXD)
/ESP32_CONSOLE_TX: U8.37 (U0TXD)
/EXP_INT: U8.28 (SPIIO6), U15.1 (~INT)
/P3V3_FB: R6.2, R7.1, U7.4 (FB)
/Q1_GATE: Q1.1 (G), R15.1
/Q2_GATE: Q2.1 (G), R16.2, R17.1
/U1_BST: C3.1, U1.7 (BST)
/U1_EN: R1.2, U1.3 (EN)
/U1_SS: C5.1, U1.10 (SS/TR)
/U1_SW: C3.2, L1.1, U1.8 (SW)
/U1_VCC: C4.1, U1.9 (VCC)
/U2_BST: C7.1, U2.6 (BST)
/U2_EN: R3.2, U2.5 (EN)
/U2_SW: C7.2, L2.1, U2.2 (SW)
/U4_CT: C13.1, U4.1 (CT)
/U5_VIN: C14.1, D1.1 (K), D2.1 (K), U5.1 (IN)
/U7_BST: C17.1, U7.6 (BST)
/U7_EN: R5.2, U7.5 (EN)
/U7_SW: C17.2, L3.1, U7.2 (SW)
/U8_BOOT: R9.2, U8.27 (GPIO0)
/U14_CT: C23.1, U14.1 (CT)
/USBC2_CC1: J9.A5 (CC1), R18.1
/USBC2_CC2: J9.B5 (CC2), R19.1
/USBC_CC1: J2.A5 (CC1), R12.1
/USBC_CC2: J2.B5 (CC2), R13.1
ALTUSB_VBUS: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), Q2.2 (S)
BMC_USB_DM: J9.A7 (D-), J9.B7 (D-), U8.13 (GPIO19)
BMC_USB_DP: J9.A6 (D+), J9.B6 (D+), U8.14 (GPIO20)
BOOTSEL: J1.26, U8.12 (GPIO8)
DCJACK_PRESENT: J5.3, R14.2, U15.13 (P10)
DCJACK_VBUS: C29.1, J5.1, Q1.2 (S), R16.1
EN_CS_U4: U8.30 (SPIDQS), U9.4 (IN)
EN_CS_U5: U8.31 (GPIO38), U10.4 (IN)
EN_SW_ALT: R22.1, R23.2, SW2.4, U14.5 (ON)
EN_SW_BMC: R20.1, R21.2, SW2.1, U4.5 (ON)
GMAC0_MDCK: J1.88, J20.3
GMAC0_MDIO: J1.87, J20.2
GMAC0_PHYCLK: J1.90, J20.5
GMAC0_RXD0: J1.95, J20.10
GMAC0_RXD1: J1.96, J20.11
GMAC0_RXDV: J1.94, J20.9
GMAC0_TXCLK: J1.89, J20.4
GMAC0_TXD0: J1.92, J20.7
GMAC0_TXD1: J1.93, J20.8
GMAC0_TXEN: J1.91, J20.6
GMAC1_MDCK: J1.114, J21.3
GMAC1_MDIO: J1.113, J21.2
GMAC1_PHYCLK: J1.116, J21.5
GMAC1_RXD0: J1.121, J21.10
GMAC1_RXD1: J1.122, J21.11
GMAC1_RXDV: J1.120, J21.9
GMAC1_TXCLK: J1.115, J21.4
GMAC1_TXD0: J1.118, J21.7
GMAC1_TXD1: J1.119, J21.8
GMAC1_TXEN: J1.117, J21.6
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, J1.5, J1.6, J1.7, J1.8, J1.11, J1.12, J1.19, J1.20, J1.21, J1.22, J1.36, J1.37, J1.38, J1.39, J1.40, J1.49, J1.51, J1.57, J1.59, J1.63, J1.66, J1.69, J1.72, J1.76, J1.79, J1.82, J1.85, J1.97, J1.102, J1.107, J1.112, J1.123, J1.130, J1.135, J1.144, J1.145, J1.147, J1.152, J1.169, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.4 (GND), J3.5 (Shield), J4.6 (VSS), J4.9 (SHIELD), J5.2, J6.G, J7.1, J7.6, J7.9, J7.12, J7.15, J8.1, J8.6, J8.9, J8.12, J8.15, J9.A1 (GND), J9.A12 (GND), J9.B1 (GND), J9.B12 (GND), J9.S1 (SHIELD), J20.1, J21.1, J22.1, J23.1, J24.1, J25.1, J26.1, J27.1, J28.1, J29.1, J30.1, J31.1, J32.1, J33.1, J34.1, J35.1, R7.2, R12.2, R13.2, R15.2, R17.2, R18.2, R19.2, R20.2, R22.2, R28.2, R30.2, R32.2, R34.2, R36.2, R38.2, R40.2, SW1.3, U1.1 (PGND), U1.4 (MODE), U1.5 (FSEL), U1.11 (GND), U2.1 (GND), U3.1 (HVC/A0), U3.4 (VSS), U3.5 (P1B), U3.10 (P0B), U3.12 (A2), U3.13 (A1), U4.6 (GND), U5.2 (GND), U6.2 (GND), U7.1 (GND), U8.1 (GND), U8.40 (GND), U8.41 (GND), U9.3 (GND), U10.3 (GND), U11.4 (GND), U12.1 (GND), U12.5 (GND), U13.4 (GND), U14.6 (GND), U15.2 (A1), U15.3 (A2), U15.12 (GND), U15.21 (A0)
GPIO0: J1.153, J30.2
GPIO1: J1.154, J30.3
GPIO2: J1.155, J30.4
GPIO3: J1.156, J30.5
GPIO4: J1.157, J30.6
GPIO5: J1.158, J30.7
GPIO6: J1.159, J30.8
GPIO7: J1.160, J30.9
GPIO8: J1.161, J30.10
GPIO9: J1.162, J30.11
GPIO10: J1.163, J30.12
GPIO11: J1.164, J30.13
GPIO12: J1.165, J30.14
GPIO13: J1.166, J30.15
GPIO14: J1.167, J30.16
GPIO15: J1.168, J30.17
HOSTED_DATA_READY: J1.48, U8.26 (GPIO45)
HOSTED_HANDSHAKE: J1.47, U8.25 (GPIO48)
HOSTED_RESET: J1.86, R8.2, U8.3 (EN)
HOSTED_SPI_CLK: J1.43, U8.8 (GPIO15)
HOSTED_SPI_CS: J1.46, U8.24 (GPIO47)
HOSTED_SPI_MISO: J1.45, U8.23 (GPIO21)
HOSTED_SPI_MOSI: J1.44, U8.9 (GPIO16)
HPOUTL: J1.58, J6.T
I2C_ID_SCL: J1.24, R42.2, U8.7 (GPIO7)
I2C_ID_SDA: J1.23, R41.2, U8.6 (GPIO6)
I2C_PWR_SCL: R26.2, U3.2 (SCL), U8.5 (GPIO5), U15.22 (SCL)
I2C_PWR_SDA: R25.2, U3.3 (SDA), U8.4 (GPIO4), U15.23 (SDA)
MIPI0_CLKN: J1.70, J7.13
MIPI0_CLKP: J1.71, J7.14
MIPI0_D0N: J1.64, J7.7
MIPI0_D0P: J1.65, J7.8
MIPI0_D1N: J1.67, J7.10
MIPI0_D1P: J1.68, J7.11
MIPI0_GPIO: J1.60, J7.2
MIPI0_SCCB_SCL: J1.62, J7.4
MIPI0_SCCB_SDA: J1.61, J7.3
MIPI1_CLKN: J1.83, J8.13
MIPI1_CLKP: J1.84, J8.14
MIPI1_D0N: J1.77, J8.7
MIPI1_D0P: J1.78, J8.8
MIPI1_D1N: J1.80, J8.10
MIPI1_D1P: J1.81, J8.11
MIPI1_GPIO: J1.73, J8.2
MIPI1_SCCB_SCL: J1.75, J8.4
MIPI1_SCCB_SDA: J1.74, J8.3
MSC0_CLK: J1.50, J4.5 (CLK)
MSC0_CMD: J1.52, J4.3 (CMD)
MSC0_D0: J1.53, J4.7 (DAT0)
MSC0_D1: J1.54, J4.8 (DAT1)
MSC0_D2: J1.55, J4.1 (DAT2)
MSC0_D3_CD: J1.56, J4.2 (DAT3/CD)
NOR_U4_CE: U9.1 (NO), U13.1 (~CS)
NOR_U5_CE: U10.1 (NO), U11.1 (~CS)
PG_SW5V: R4.2, U4.7 (PG), U15.7 (P03)
PG_SW5V_ALT: R24.2, U14.7 (PG), U15.9 (P05)
PG_VCORE: R2.2, U1.6 (PG), U15.8 (P04)
PWM0: J1.136, J27.2
PWM1: J1.137, J27.3
PWM2: J1.138, J27.4
PWM3: J1.139, J27.5
PWM4: J1.140, J27.6
PWM5: J1.141, J27.7
PWM6: J1.142, J27.8
PWM7: J1.143, J27.9
RESET_EN: J1.27, U8.15 (GPIO3)
SAR_AUX0: J1.146, J28.2
SFC_CLK: J1.29, U8.20 (GPIO12), U11.6 (CLK), U13.6 (CLK)
SFC_CS: J1.28, U8.18 (GPIO10), U9.2 (COM), U10.2 (COM)
SFC_IO0: J1.30, U8.19 (GPIO11), U11.5 (DI(IO0)), U13.5 (DI(IO0))
SFC_IO1: J1.31, U8.21 (GPIO13), U11.2 (DO(IO1)), U13.2 (DO(IO1))
SFC_IO2: J1.32, U8.22 (GPIO14), U11.3 (IO2), U13.3 (IO2)
SFC_IO3: J1.33, U8.17 (GPIO9), U11.7 (IO3), U13.7 (IO3)
SMB0_SCK: J1.149, J29.3
SMB0_SDA: J1.148, J29.2
SMB1_SCK: J1.151, J29.5
SMB1_SDA: J1.150, J29.4
SPARE_P170: J1.170, J31.2
SPARE_P171: J1.171, J31.3
SPARE_P172: J1.172, J31.4
SPARE_P173: J1.173, J31.5
SPARE_P174: J1.174, J31.6
SPARE_P175: J1.175, J31.7
SPARE_P176: J1.176, J31.8
SPARE_P177: J1.177, J31.9
SPARE_P178: J1.178, J31.10
SPARE_P179: J1.179, J31.11
SPARE_P180: J1.180, J31.12
SPARE_P181: J1.181, J31.13
SPARE_P182: J1.182, J31.14
SPARE_P183: J1.183, J31.15
SPARE_P184: J1.184, J31.16
SPARE_P185: J1.185, J31.17
SPARE_P186: J1.186, J31.18
SPARE_P187: J1.187, J31.19
SPARE_P188: J1.188, J31.20
SPARE_P189: J1.189, J31.21
SPARE_P190: J1.190, J31.22
SPARE_P191: J1.191, J31.23
SPARE_P192: J1.192, J31.24
SPARE_P193: J1.193, J32.2
SPARE_P194: J1.194, J32.3
SPARE_P195: J1.195, J32.4
SPARE_P196: J1.196, J32.5
SPARE_P197: J1.197, J32.6
SPARE_P198: J1.198, J32.7
SPARE_P199: J1.199, J32.8
SPARE_P200: J1.200, J32.9
SPARE_P201: J1.201, J32.10
SPARE_P202: J1.202, J32.11
SPARE_P203: J1.203, J32.12
SPARE_P204: J1.204, J32.13
SPARE_P205: J1.205, J32.14
SPARE_P206: J1.206, J32.15
SPARE_P207: J1.207, J32.16
SPARE_P208: J1.208, J32.17
SPARE_P209: J1.209, J32.18
SPARE_P210: J1.210, J32.19
SPARE_P211: J1.211, J32.20
SPARE_P212: J1.212, J32.21
SPARE_P213: J1.213, J32.22
SPARE_P214: J1.214, J32.23
SPARE_P215: J1.215, J32.24
SPARE_P216: J1.216, J32.25
SPARE_P217: J1.217, J33.2
SPARE_P218: J1.218, J33.3
SPARE_P219: J1.219, J33.4
SPARE_P220: J1.220, J33.5
SPARE_P221: J1.221, J33.6
SPARE_P222: J1.222, J33.7
SPARE_P223: J1.223, J33.8
SPARE_P224: J1.224, J33.9
SPARE_P225: J1.225, J33.10
SPARE_P226: J1.226, J33.11
SPARE_P227: J1.227, J33.12
SPARE_P228: J1.228, J33.13
SPARE_P229: J1.229, J33.14
SPARE_P230: J1.230, J33.15
SPARE_P231: J1.231, J33.16
SPARE_P232: J1.232, J33.17
SPARE_P233: J1.233, J33.18
SPARE_P234: J1.234, J33.19
SPARE_P235: J1.235, J33.20
SPARE_P236: J1.236, J33.21
SPARE_P237: J1.237, J33.22
SPARE_P238: J1.238, J33.23
SPARE_P239: J1.239, J33.24
SPARE_P240: J1.240, J33.25
SPARE_P241: J1.241, J34.2
SPARE_P242: J1.242, J34.3
SPARE_P243: J1.243, J34.4
SPARE_P244: J1.244, J34.5
SPARE_P245: J1.245, J34.6
SPARE_P246: J1.246, J34.7
SPARE_P247: J1.247, J34.8
SPARE_P248: J1.248, J34.9
SPARE_P249: J1.249, J34.10
SPARE_P250: J1.250, J34.11
SPARE_P251: J1.251, J34.12
SPARE_P252: J1.252, J34.13
SPARE_P253: J1.253, J34.14
SPARE_P254: J1.254, J34.15
SPARE_P255: J1.255, J34.16
SPARE_P256: J1.256, J34.17
SPARE_P257: J1.257, J34.18
SPARE_P258: J1.258, J34.19
SPARE_P259: J1.259, J34.20
SPARE_P260: J1.260, J34.21
SPARE_P261: J1.261, J34.22
SPARE_P262: J1.262, J34.23
SPARE_P263: J1.263, J34.24
SPARE_P264: J1.264, J34.25
SPARE_P265: J1.265, J35.2
SPARE_P266: J1.266, J35.3
SPARE_P267: J1.267, J35.4
SPARE_P268: J1.268, J35.5
SPARE_P269: J1.269, J35.6
SPARE_P270: J1.270, J35.7
SPARE_P271: J1.271, J35.8
SPARE_P272: J1.272, J35.9
SPARE_P273: J1.273, J35.10
SPARE_P274: J1.274, J35.11
SPARE_P275: J1.275, J35.12
SPARE_P276: J1.276, J35.13
SPARE_P277: J1.277, J35.14
SPARE_P278: J1.278, J35.15
SPARE_P279: J1.279, J35.16
SPARE_P280: J1.280, J35.17
SPARE_P281: J1.281, J35.18
SPARE_P282: J1.282, J35.19
SPARE_P283: J1.283, J35.20
SPARE_P284: J1.284, J35.21
SPARE_P285: J1.285, J35.22
SPARE_P286: J1.286, J35.23
SPARE_P287: J1.287, J35.24
SPARE_P288: J1.288, J35.25
SSI0_CE0: J1.127, J25.5
SSI0_CE1: J1.128, J25.6
SSI0_CLK: J1.124, J25.2
SSI0_DR: J1.126, J25.4
SSI0_DT: J1.125, J25.3
SSI0_GPC: J1.129, J25.7
SSI1_CE0: J1.134, J26.5
SSI1_CLK: J1.131, J26.2
SSI1_DR: J1.133, J26.4
SSI1_DT: J1.132, J26.3
SW5V_EN_ALT: R23.1, U8.16 (GPIO46)
SW5V_EN_BMC: R21.1, U8.38 (GPIO2)
SW_SENSE_1: R10.2, SW1.1, U15.10 (P06)
SW_SENSE_4: R11.2, SW1.4, U15.11 (P07)
UART0_CTS: J1.100, J22.4
UART0_RTS: J1.101, J22.5
UART0_RXD: J1.98, J22.2
UART0_TXD: J1.99, J22.3
UART1_RX: J1.35, U8.11 (GPIO18)
UART1_TX: J1.34, U8.10 (GPIO17)
UART2_CTS: J1.105, J23.4
UART2_RTS: J1.106, J23.5
UART2_RXD: J1.103, J23.2
UART2_TXD: J1.104, J23.3
UART3_CTS: J1.110, J24.4
UART3_RTS: J1.111, J24.5
UART3_RXD: J1.108, J24.2
UART3_TXD: J1.109, J24.3
USB1_VBUS_OUT: J3.1 (VBUS), U12.15 (OUT1)
USB2_VBUS_OUT: U12.14 (OUT2)
USB3_VBUS_OUT: U12.11 (OUT3)
USBA_HOST_DM: J1.42, J2.A7 (D-), J2.B7 (D-), J3.2 (D-)
USBA_HOST_DP: J1.41, J2.A6 (D+), J2.B6 (D+), J3.3 (D+)
USB_EN1: U12.3 (EN1), U15.4 (P00)
USB_EN2: U12.4 (EN2), U15.5 (P01)
USB_EN3: U12.7 (EN3), U15.6 (P02)
USB_OC1: U8.32 (MTCK), U12.16 (OC1)
USB_OC2: U8.33 (MTDO), U12.13 (OC2)
USB_OC3: U8.34 (MTDI), U12.12 (OC3)
VCORE: C9.1, C10.1, J1.1, J1.2, J1.3, J1.4, L1.2, R27.1, R29.1, R31.1, R33.1, U3.8 (P0A)
VCORE_FB_0V8: JP2.2, R27.2, R28.1
VCORE_FB_0V9: JP3.2, R29.2, R30.1
VCORE_FB_1V0: JP4.2, R31.2, R32.1
VCORE_FB_1V1: JP5.2, R33.2, R34.1
VCORE_FB_DIGIPOT: JP6.2, U3.9 (P0W)
VCORE_FB_SEL: JP2.1, JP3.1, JP4.1, JP5.1, JP6.1, U1.12 (FB)
VCORE_SNS: J1.25, U8.39 (GPIO1)
VDDR: C11.1, J1.9, J1.10, L2.2, R35.1, R37.1, R39.1, U3.7 (P1A)
VDDR_FB_1V5: JP8.2, R37.2, R38.1
VDDR_FB_1V8: JP9.2, R39.2, R40.1
VDDR_FB_1V35: JP7.2, R35.2, R36.1
VDDR_FB_DIGIPOT: JP10.2, U3.6 (P1W)
VDDR_FB_SEL: JP7.1, JP8.1, JP9.1, JP10.1, U2.4 (FB)

Notes on the sheet:
POWER
DDR4 UDIMM-288 CONNECTOR
BMC - ESP32-S3
CARRIER PHYSICAL I/O
PIN BREAKOUT HEADERS
VCORE VOLTAGE SELECT
VDDR VOLTAGE SELECT
GMAC0 (RGMII0)
GMAC1 (RGMII1, A1 2nd MAC)
SSI0 (SPI master)
PWM0-7
GPIO0-15 (plain)
UART0
UART2
UART3
SSI1
SAR-ADC
SMB0/SMB1 (general I2C)
J1 SPARE (P170-192)
J1 SPARE (P193-216)
J1 SPARE (P217-240)
J1 SPARE (P241-264)
J1 SPARE (P265-288)

Board: 4 copper layers, 128 parts (0 on the bottom side), 308 nets, no tracks yet.
